# Keil uVision project stm32_lwip.uvprojx, settings and files
target stm32_lwip (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_lwip +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Drivers\LED;.\Drivers\NVIC;.\Drivers\TIMER;.\Drivers\USART;.\Drivers\KEY;.\Drivers\SYS;.\Drivers\DELAY;.\Drivers\lwip-1.4.1\netif\ppp;.\Drivers\lwip-1.4.1\include\lwip;.\Drivers\lwip-1.4.1\include\ipv4;.\Drivers\lwip-1.4.1\include;.\Drivers\lwip-1.4.1;.\Drivers\lwip-1.4.1\arch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ./: main.c
  group Drivers
    ./Drivers/LED/: led.c
    ./Drivers/NVIC/: NVIC.c
    ./Drivers/TIMER/: Timer.c
    ./Drivers/USART/: usart1.c usart2.c
    ./Drivers/KEY/: key.c
    ./Drivers/DELAY/: delay.c
    ./Drivers/SYS/: sys1.c
  group LWIP_netif_PPP
    ./Drivers/lwip-1.4.1/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group LWIP_CORE
    ./Drivers/lwip-1.4.1/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP_CORE_IPV4
    ./Drivers/lwip-1.4.1/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP_ARCH
    ./Drivers/lwip-1.4.1/arch/: sio.c sys_arch.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, RTOS:uC/OS Kernel 1.0.0
